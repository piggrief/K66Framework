# IAR project LQ_K66FX_LPTMR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FX1M0xxx18 NXP MK66FX1M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ARM_MATH_CM4
  ICCARM.CCIncludePath2: src\Includes; src\Libs; src\User
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LQ_K66FX_LPTMR.hex
  ILINK.IlinkOutputFile: LQ_K66FX_LPTMR.out
  ILINK.IlinkIcfFile: src\Project_Setting\Linker_Files\LQK66FLASH1M.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: LQ_K66FX_OLED.hex
  group Driver/ADC
    src/Source/: ADC.c
    src/Includes/: ADC.h
  group Driver/DMA
    src/Source/: DMA.c
    src/Includes/: DMA.h
  group Driver/FTM
    src/Source/: FTM.c
    src/Includes/: FTM.h
  group Driver/GPIO
    src/Source/: GPIO.c
    src/Includes/: GPIO.h GPIO_Cfg.h
  group Driver/IIC
    src/Source/: I2C.c
    src/Includes/: I2C.h
  group Driver/LPTMR
    src/Source/: LPTMR.c
    src/Includes/: Lptmr.h
  group Driver/PIT
    src/Source/: PIT.c
    src/Includes/: PIT.h
  group Driver/PLL
    src/Source/: PLL.c
    src/Includes/: PLL.h
  group Driver/RTC
    src/Source/: RTC.c
    src/Includes/: RTC.h
  group Driver/SPI
    src/Source/: SPI.c
    src/Includes/: SPI.h
  group Driver/Systick
    src/Source/: Systick.c
    src/Includes/: Systick.h
  group Driver/TFT1.44
    src/Source/: TFTDriver.c
    src/Includes/: TFTDriver.h
  group Driver/UART
    src/Source/: UART.c
    src/Includes/: UART.h
  group Driver/Vectors
    src/Source/: vectors.c
    src/Includes/: vectors.h
  group Driver/WDOG
    src/Source/: wdog.c
    src/Includes/: wdog.h
  group header
    src/Libs/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm4.h MK66F18.h
  group Include
    src/Source/: common.c
    src/Includes/: common.h
    src/User/: include.h
  group Start up
    src/Project_Setting/Startup/: crt0.s start.c
  group User
    src/Source/: LQ12864.c LQKEY.c LQLED.c
    src/Includes/: LQ12864.h LQKEY.h LQLED.h
    src/User/: main.c
  group User/Debug
    src/User/: DebugFuction.c DebugFunction.h
  group User/image_deal
    src/User/: image_deal.c image_deal.h
  group User/MecanumWheelControl
    src/User/: MecanumWheelControl.c MecanumWheelControl.h
  group User/MPU6050
    src/User/: MPU6050Drive.c MPU6050Drive.h
  group User/SEEKFREE
    src/User/: SEEKFREE_MT9V032.c SEEKFREE_MT9V032.h
  group User/Sensor
    src/User/: AttitudeCalculation.c AttitudeCalculation.h
